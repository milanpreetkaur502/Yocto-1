
require bluepy.inc

PV = "1.3.0"
SRCREV = "dc33285f31a873fab92c22e8839c44899f82b041"
